# Keil uVision project us100.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: us100 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\US100;..\USER\TIMER;..\USER\USART
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/USART/: usart.c
    ../USER/TIMER/: timer.c
    ../USER/US100/: US100.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group Common
    ../Common/: common.c
